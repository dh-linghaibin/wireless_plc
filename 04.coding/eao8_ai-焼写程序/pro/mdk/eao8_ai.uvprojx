# Keil uVision project eao8_ai.uvprojx, settings and files
target master (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103VC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: eao8_ai +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=2
  c include: ..\..\device\include;..\..\user\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../../user/: main.c
  group device
    ../../device/: delay.c read_config.c analog_quantity.c sign_led.c can.c config.c flash.c
software components: CMSIS:CORE 5.1.1, Device:GD32F10x_StdPeripherals:ADC 2.0.0, Device:GD32F10x_StdPeripherals:BKP 2.0.0, Device:GD32F10x_StdPeripherals:CAN 2.0.0, Device:GD32F10x_StdPeripherals:CRC 2.0.0, Device:GD32F10x_StdPeripherals:DAC 2.0.0, Device:GD32F10x_StdPeripherals:DBG 2.0.0, Device:GD32F10x_StdPeripherals:DMA 2.0.0, Device:GD32F10x_StdPeripherals:ENET 2.0.0, Device:GD32F10x_StdPeripherals:EXMC 2.0.0, Device:GD32F10x_StdPeripherals:EXTI 2.0.0, Device:GD32F10x_StdPeripherals:FMC 2.0.0, Device:GD32F10x_StdPeripherals:FWDGT 2.0.0, Device:GD32F10x_StdPeripherals:GPIO 2.0.0, Device:GD32F10x_StdPeripherals:I2C 2.0.0, Device:GD32F10x_StdPeripherals:MISC 2.0.0, Device:GD32F10x_StdPeripherals:PMU 2.0.0, Device:GD32F10x_StdPeripherals:RCU 2.0.0, Device:GD32F10x_StdPeripherals:RTC 2.0.0, Device:GD32F10x_StdPeripherals:SDIO 2.0.0, Device:GD32F10x_StdPeripherals:SPI_I2S 2.0.0, Device:GD32F10x_StdPeripherals:TIMER 2.0.0, Device:GD32F10x_StdPeripherals:USART 2.0.0, Device:GD32F10x_StdPeripherals:WWDGT 2.0.0, Device:GD32F10x_libopt 2.0.0, Device:Startup 2.0.0
