# Keil uVision project wireless_oia.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: wireless_oia
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\device\include;..\..\device\wireless;..\..\user\include;..\..\kernel\software\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../../user/: main.c
  group devices
    ../../device/: tm1650.c sign_led.c wireless.c sign_configure.c delay.c si446x.c can.c wdog.c timer.c
  group software
    ../../kernel/software/multiButton/: multi_button.c
    ../../kernel/software/multiTimer/: multi_timer.c
software components: CMSIS:CORE 5.0.0, Device:GD32F10x_StdPeripherals:ADC 2.0.0, Device:GD32F10x_StdPeripherals:BKP 2.0.0, Device:GD32F10x_StdPeripherals:CAN 2.0.0, Device:GD32F10x_StdPeripherals:CRC 2.0.0, Device:GD32F10x_StdPeripherals:DAC 2.0.0, Device:GD32F10x_StdPeripherals:DBG 2.0.0, Device:GD32F10x_StdPeripherals:DMA 2.0.0, Device:GD32F10x_StdPeripherals:ENET 2.0.0, Device:GD32F10x_StdPeripherals:EXMC 2.0.0, Device:GD32F10x_StdPeripherals:EXTI 2.0.0, Device:GD32F10x_StdPeripherals:FMC 2.0.0, Device:GD32F10x_StdPeripherals:FWDGT 2.0.0, Device:GD32F10x_StdPeripherals:GPIO 2.0.0, Device:GD32F10x_StdPeripherals:I2C 2.0.0, Device:GD32F10x_StdPeripherals:MISC 2.0.0, Device:GD32F10x_StdPeripherals:PMU 2.0.0, Device:GD32F10x_StdPeripherals:RCU 2.0.0, Device:GD32F10x_StdPeripherals:RTC 2.0.0, Device:GD32F10x_StdPeripherals:SDIO 2.0.0, Device:GD32F10x_StdPeripherals:SPI_I2S 2.0.0, Device:GD32F10x_StdPeripherals:TIMER 2.0.0, Device:GD32F10x_StdPeripherals:USART 2.0.0, Device:GD32F10x_StdPeripherals:WWDGT 2.0.0, Device:GD32F10x_libopt 2.0.0, Device:Startup 2.0.0
