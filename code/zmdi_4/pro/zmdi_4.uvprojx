# Keil uVision project zmdi_4.uvprojx, settings and files
target zmdi_4 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F042G4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x1800) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: zmdi_4
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\arch\Include;..\arch\lib\inc;..\arch\cmsis;..\device\include;..\user\include;..\freertos\include;..\freertos\portable\MemMang;..\freertos\portable\RVDS\ARM_CM0
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group user
    ../user/: app.c task_set.c task_can.c
  group arch
    ../arch/lib/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group device
    ../device/: can.c wdog.c digital_tube.c sys.c flash.c button.c insignal.c
  group freertos
    ../freertos/: croutine.c list.c queue.c tasks.c timers.c
  group freertos_port
    ../freertos/portable/RVDS/ARM_CM0/: port.c
    ../freertos/portable/MemMang/: heap_2.c
software components: CMSIS:CORE 5.1.1, Device:Startup 2.2.3
