# Keil uVision project zmdo_4.uvprojx, settings and files
target zmdo+4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: zmdo_4
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\device\include;..\freertos\include;..\user\include;..\freertos\portable\RVDS\ARM_CM3;..\modbus_master
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../user/: app.c task_can.c task_set.c task_modbus.c
  group device
    ../device/: can.c flash.c wdog.c delay.c button.c digital_tube.c rs485.c
  group freertos
    ../freertos/: list.c queue.c tasks.c timers.c
    ../freertos/portable/MemMang/: heap_2.c
    ../freertos/portable/RVDS/ARM_CM3/: port.c
  group modbus_master
    ../modbus_master/: modbus_master.c ringbuffer.c trans_recieve_buff_control.c
software components: CMSIS:CORE 5.1.1, Device:GD32F10x_StdPeripherals:ADC 2.0.0, Device:GD32F10x_StdPeripherals:BKP 2.0.0, Device:GD32F10x_StdPeripherals:CAN 2.0.0, Device:GD32F10x_StdPeripherals:CRC 2.0.0, Device:GD32F10x_StdPeripherals:DAC 2.0.0, Device:GD32F10x_StdPeripherals:DBG 2.0.0, Device:GD32F10x_StdPeripherals:DMA 2.0.0, Device:GD32F10x_StdPeripherals:ENET 2.0.0, Device:GD32F10x_StdPeripherals:EXMC 2.0.0, Device:GD32F10x_StdPeripherals:EXTI 2.0.0, Device:GD32F10x_StdPeripherals:FMC 2.0.0, Device:GD32F10x_StdPeripherals:FWDGT 2.0.0, Device:GD32F10x_StdPeripherals:GPIO 2.0.0, Device:GD32F10x_StdPeripherals:I2C 2.0.0, Device:GD32F10x_StdPeripherals:MISC 2.0.0, Device:GD32F10x_StdPeripherals:PMU 2.0.0, Device:GD32F10x_StdPeripherals:RCU 2.0.0, Device:GD32F10x_StdPeripherals:RTC 2.0.0, Device:GD32F10x_StdPeripherals:SDIO 2.0.0, Device:GD32F10x_StdPeripherals:SPI_I2S 2.0.0, Device:GD32F10x_StdPeripherals:TIMER 2.0.0, Device:GD32F10x_StdPeripherals:USART 2.0.0, Device:GD32F10x_StdPeripherals:WWDGT 2.0.0, Device:GD32F10x_libopt 2.0.0, Device:Startup 2.0.0
