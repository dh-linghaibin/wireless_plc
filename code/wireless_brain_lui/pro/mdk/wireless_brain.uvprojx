# Keil uVision project wireless_brain.uvprojx, settings and files
target brain (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wireless_brain +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,USE_EMBEDDED_PHY
  c include: ..\..\device\include;..\..\user\include;..\..\arch\m4\inc;..\..\arch\m4\core;..\..\lib\include;..\..\arch\m4\eth\inc;..\..\software\fatfs\src;..\..\software\fatfs\exfuns;..\..\software\lwip;..\..\software\lwip\lwip-1.4.1\src\include;..\..\software\lwip\lwip-1.4.1\src\include\ipv4;..\..\software\lwip\lwip-1.4.1\src\include\lwip;..\..\software\lwip\lwip-1.4.1\src\include\netif;..\..\software\lwip\lwip_app\lwip_comm;..\..\software\freertos\include;..\..\software\freertos\portable\RVDS\ARM_CM4F;..\..\software\ugui;..\..\software\lvgl\lvgl-master\lv_core;..\..\software\lua-5.3.4;..\..\software\lwip\port;..\..\software\lwip\port\include\arch\;..\..\software\lwip\port\include\;..\..\software\lwip\src\include;..\..\software\lwip\src\include\ipv4;..\..\software\lwip\src\include\lwip;..\..\software\lwip\src\netif;..\..\software\freertos\include;..\..\software\freertos\portable\ARM_CM4F;..\..\software\freemodbus\modbus\tcp;..\..\software\freemodbus\modbus\include;..\..\software\freemodbus\port;..\..\arch\m4\usb_otg\inc;..\..\software\usb_port\include;..\..\arch\m4\usb_device\Core\inc;..\..\arch\m4\usb_device\Class\msc\inc;..\..\arch\m4\usb_port;..\..\software\lua-5.3.4\port\include;..\..\software\ini\src;..\..\ui\include;..\..\software\tool\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../../user/: app.c task_file.c task_gui.c task_can.c task_modbus.c task_lua.c
  group tool
    ../../software/tool/: persistence.c
  group fatfs
    ../../software/fatfs/src/: diskio.c ff.c
    ../../software/fatfs/src/option/: cc936.c
    ../../software/fatfs/exfuns/: exfuns.c
  group software
    ../../lib/: malloc.c l_list.c
  group device
    ../../device/: delay.c spi.c sram.c tft.c usart.c xpt2046.c w25qxx.c core_temp.c timer.c button.c can.c lan8720.c rtc.c buzzer.c rs485.c iwdg.c
  group arch
    ../../arch/m4/core/: startup_stm32f40_41xxx.s stm32f4xx_it.c system_stm32f4xx.c
    ../../arch/m4/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../arch/m4/eth/src/: stm32f4x7_eth.c
  group lua
    ../../software/lua-5.3.4/: lapi.c lauxlib.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lundump.c lutf8lib.c lvm.c lzio.c
  group lua_port
    ../../software/lua-5.3.4/port/: lua_if.c equipment.c lua_api.c ltime.c levent.c
    ../../software/lua-5.3.4/: lua.c
  group lwip_core
    ../../software/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../software/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../software/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../software/lwip/src/netif/: etharp.c
  group lwip_port
    ../../software/lwip/port/: ethernetif.c sys_arch.c
  group freertos_core
    ../../software/freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group freertos_port
    ../../software/freertos/portable/ARM_CM4F/: port.c
    ../../software/freertos/portable/MemMang/: heap_3.c
  group freemodbus
    ../../software/freemodbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../software/freemodbus/modbus/tcp/: mbtcp.c
    ../../software/freemodbus/modbus/: mb.c
    ../../software/freemodbus/port/: portevent.c porttcp.c
  group usb_device
    ../../arch/m4/usb_device/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../arch/m4/usb_device/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group usb_otg
    ../../arch/m4/usb_otg/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group usb_port
    ../../arch/m4/usb_port/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group doc
    ../../doc/: readme.txt
